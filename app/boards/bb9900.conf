## app/boards/bb9900.conf
```kconfig
CONFIG_I2C=Y
CONFIG_SENSOR=N
CONFIG_I2C_NRFX=Y
CONFIG_LOG=y
CONFIG_SENSOR_LOG_LEVEL_DBG=n
CONFIG_INPUT_A320=y
CONFIG_INPUT_A320_POLLINGRATE=100
```
